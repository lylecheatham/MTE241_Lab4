# Keil uVision project MTE241_Lab4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: MTE241_Lab4
  c flags: Optim=1
  c define: __RTGT_UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group ext
    ./src/ext/: GLCD_Scroll.c GLCD_SPI_LPC1700.c Retarget.c RTX_config.c system_LPC17xx.c uart.c startup_LPC17xx.s
  group lib
    ./src/lib/: button.c joystick.c led.c pot.c util.c error.c
  group src
    ./src/: main.c
    ./src/tasks/button/: button_task.c
    ./src/tasks/game_loop/: display.c game_loop_task.c game_state.c laser.c ships.c
    ./src/tasks/joystick/: joystick_task.c
    ./src/tasks/score/: score_task.c
